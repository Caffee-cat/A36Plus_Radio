# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F330CB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: D:\1-MyFiles\2-Dev\3-A36Plus\Tools\kdhx_tools.exe -e "$L@L.bin" "$L@L.kdhx"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,GD32F3X0,GD32F330,LV_CONF_INCLUDE_SIMPLE
  c misc: --no-multibyte-chars
  c include: ..\Libraries\GD32\CMSIS\GD\GD32F3x0\Include;..\Libraries\GD32\CMSIS\Keil;..\Users\Inc;..\Libraries\GD32\CMSIS\GD\GD32F3x0\Source\ARM;..\Libraries\GD32\GD32F3x0_standard_peripheral\Include;.cmsis\include;RTE\_GD32F330;.eide\deps;..\Libraries\GD32;..\Core\Inc;..\APP;..\Drivers\LCD;..\Drivers\Flash;..\Drivers\BK4819;..\Drivers\BK1080;..\Drivers\Key;..\Drivers\FMC;..\Drivers\FONT;..\Libraries\FreeRTOS-Kernel\include;..\Libraries\FreeRTOS-Kernel\portable\RVDS\ARM_CM4F;..\Libraries\lvgl\src;..\GUI;RTE\_Project
  asm define: as above
  memory RVCT4: ROM 0x8001000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group ../LIBRARIES/PRINTF
    ../Libraries/printf/: printf.c
  group ../LIBRARIES/LVGL/SRC/LV_WIDGETS
    ../Libraries/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group ../LIBRARIES/LVGL/SRC/LV_THEMES
    ../Libraries/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
  group ../LIBRARIES/LVGL/SRC/LV_MISC
    ../Libraries/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt_ap.c lv_txt.c lv_utils.c
  group ../LIBRARIES/LVGL/SRC/LV_HAL
    ../Libraries/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group ../LIBRARIES/LVGL/SRC/LV_GPU
    ../Libraries/lvgl/src/lv_gpu/: lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
  group ../LIBRARIES/LVGL/SRC/LV_FONT
    ../Libraries/lvgl/src/lv_font/: lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12_subpx.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28_compressed.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_font.c
  group ../LIBRARIES/LVGL/SRC/LV_DRAW
    ../Libraries/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group ../LIBRARIES/LVGL/SRC/LV_CORE
    ../Libraries/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/HOST/CLASS/HID/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/HOST/CLASS/MSC/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/HOST/CORE/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DRIVER/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/driver/Source/: drv_usbd_int.c drv_usbh_int.c drv_usb_core.c drv_usb_dev.c drv_usb_host.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CLASS/AUDIO/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/class/audio/Source/: audio_core.c audio_out_itf.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CLASS/CDC/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CLASS/DFU/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/class/dfu/Source/: dfu_core.c dfu_mem.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CLASS/HID/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/class/hid/Source/: custom_hid_core.c standard_hid_core.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CLASS/IAP/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/class/iap/Source/: usb_iap_core.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CLASS/MSC/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CLASS/PRINTER/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/class/printer/Source/: printer_core.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CORE/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group ../LIBRARIES/GD32/GD32F3X0_STANDARD_PERIPHERAL/SOURCE
    ../Libraries/GD32/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group ../LIBRARIES/GD32/CMSIS/GD/GD32F3X0/SOURCE
    ../Libraries/GD32/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group ../LIBRARIES/GD32/CMSIS/GD/GD32F3X0/SOURCE/ARM
    ../Libraries/GD32/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group ../LIBRARIES/GD32/CMSIS/GD/GD32F3X0/SOURCE/GNU
    ../Libraries/GD32/CMSIS/GD/GD32F3x0/Source/GNU/: startup_gd32f3x0.s
  group ../LIBRARIES/GD32/CMSIS/GD/GD32F3X0/SOURCE/IAR
    ../Libraries/GD32/CMSIS/GD/GD32F3x0/Source/IAR/: startup_gd32f3x0.s
  group ../LIBRARIES/FREERTOS
    ../Libraries/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Libraries/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../Libraries/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c
  group ../DRIVERS/LCD
    ../Drivers/LCD/: jgfx.c st7735s.c backlight.c
  group ../DRIVERS/KEY
    ../Drivers/Key/: key.c
    ../Drivers/LCD/: backlight.c
  group ../DRIVERS/FLASH
    ../Drivers/Flash/: w25q16jv.c
  group ../DRIVERS/BK4819
    ../Drivers/BK4819/: bk4819.c
  group ../DRIVERS/BK1080
    ../Drivers/BK1080/: bk1080.c
  group ../DRIVERS/FONT
    ../Drivers/Font/: Font.c
  group ../DRIVERS/FMC
    ../Drivers/FMC/: fmc.c
  group ../GUI/SRC
    ../GUI/: ui_menu.c ui.c ui_stack.c ui_main.c comp_menu.c
  group ../CORE/SRC
    ../Core/Src/: dma.c gpio.c nvic.c spi.c tim.c usart.c adc.c
  group ../USERS/SRC
    ../Users/Src/: gd32f3x0_it.c lv_port_disp.c main.c my_tasks.c pwr_det.c systick.c test.c usart_flash.c
  group ../APP
    ../APP/: radio.c
